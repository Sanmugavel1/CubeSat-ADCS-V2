options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '8'
    samp_rate: 2.048e6
    taps: |
      firdes.low_pass(1.0, 2.048e6, 62.5e3, 10e3)
    type: ccc
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: 433e6
    channel_list: '[433e6]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: 256e3
    sf: '7'
  states: {}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '0'
    port: '40868'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 432.9925e6
    gain0: '28'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.048e6
    sync: sync
    type: fc32
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', lora_lora_receiver_0, '0']
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
